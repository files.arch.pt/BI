Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2018-07-27T14:49:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jul 27 14:49:22 2018 * Host: GoferDesign * Database: C:\Users\Asus\AppData\Local\Temp\{05EA636B-7C72-40C3-A323-72B078EC8397}\ifc * Database version: 5507 * Database creation date: Fri Jul 27 14:49:20 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jul 27 14:49:20 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jul 27 14:49:20 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: Washbasin, 39357002:Washbasin:18503
In: Level 1
Classification: 39357002 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Arch Valadares
Pset_DistributionFlowElementCommon - Reference: Washbasin
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.2101 m2; Volume: 0.0119236 m3; Height: 120 mm; Length: 500 mm; Width: 400 mm
Identity Data - Mark: 22; Assembly Code: 39357002; Description: Washbasin Counter Top; Manufacturer: Arch Valadares; Model: EGG; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: Washbasin; URL: www.archvaladares.com
Other - Category: Plumbing Fixtures; Family: 39357002: Washbasin; Family and Type: 39357002: Washbasin; Type: 39357002: Washbasin; Type Id: 39357002: Washbasin; Family Name: 39357002
Phasing - Phase Created: New Construction
Text - Technical Warranty: 20 Years; Country of Origin: Portugal; Load test (Standard EN): EN 14688:2006; Mechanical resistance (material): 510 kgf/cm2; Performance Certificate: DoP N.14688; Weight: 7.2
Materials and Finishes - Material: Gresanit
