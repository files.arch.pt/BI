Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-08-06T14:39:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.0.0.383 - Exporter 21.0.0.383 - IU alternativa 21.0.0.383
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 06 14:39:15 2021 * Host: GoferDesign * Database: C:\Users\Asus\AppData\Local\Temp\54045824-5c1d-4739-bd0e-933191e42414\cfc6cb0a-e841-4278-8fc6-fd4d3c1f0707\ifc * Database version: 5507 * Database creation date: Fri Aug 06 14:39:13 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 06 14:39:13 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 06 14:39:13 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:8 mm Extremidade superior, Nível 1
LongName: Nível 1; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Outros(Type) - Categoria: Níveis; Nome da família: Nível
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível- Círculo: M_Cabeça do nível- Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes
Dados de identidade(Type) - Nome do tipo: 8 mm Extremidade superior
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 1
Outros - Categoria: Níveis; Família: Nível: 8 mm Extremidade superior; Família e tipo: Nível: 8 mm Extremidade superior; ID de tipo: Nível: 8 mm Extremidade superior; Tipo: Nível: 8 mm Extremidade superior
Restrições - Elevação: 0 mm

# IfcFlowTerminal: 100-42-Lav:Washbasin, 100-42-Lav:Washbasin:335051
In: Nível 1
Type - Classification: 42350002C (Uniformat); Material: Gresanit
Type - Cotas - Height: 140 mm; Length: 400 mm; Width: 400 mm
Type - Dados de identidade - Código de montagem: 42350002C; Descrição: Washbasin; Fabricante: Arch Valadares; Modelo: ONE; Nome do tipo: Washbasin; Número OmniClass: 23.45.00.00; Título OmniClass: Sanitary, Laundry, and Cleaning Equipment; URL: www.archvaladares.com
Type - Materiais e acabamentos - Material: Gresanit
Type - Outros - Categoria: Peças hidrossanitárias; Nome da família: 100-42-Lav
Type - Restrições - Elevação padrão: 0 mm
Type - Texto - Country of Origin: Portugal; Load test (Standard EN): EN 14688:2006; Mechanical resistance (material): 510 kgf/cm2; Performance Certificate: DoP N.14688; Technical Warranty: 20 Years; Weight: 7.5 kg
Type - Pset_ManufacturerTypeInformation - Manufacturer: Arch Valadares
Type - Pset_QuantityTakeOff - Reference: Washbasin
Pset_DistributionFlowElementCommon - Reference: Washbasin; sets with these values: 2
Cotas - Área: 0.355038 m2; Volume: 0.00844883 m3
Dados de identidade - Marca: 25
Fase - Fase criada: Fase 1
Outros - Família: 100-42-Lav: Washbasin; Família e tipo: 100-42-Lav: Washbasin; ID de tipo: 100-42-Lav: Washbasin; Tipo: 100-42-Lav: Washbasin
Restrições - Deslocamento do hospedeiro: 0 mm; Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 1; Move com elementos próximos: no; Nível: Nível: Nível 1
