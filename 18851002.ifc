Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2018-09-04T10:32:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 04 10:32:05 2018 * Host: GoferDesign * Database: C:\Users\Asus\AppData\Local\Temp\{855CE000-607F-4852-9DC4-21547A36AE1D}\ifc * Database version: 5507 * Database creation date: Tue Sep 04 10:32:02 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 04 10:32:03 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 04 10:32:03 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: Washbasin, 18851002:Washbasin:3863
In: Level 1
Classification: 18851002 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Arch Valadares
Pset_DistributionFlowElementCommon - Reference: Washbasin
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.203499 m2; Volume: 0.00186146 m3; Height: 110 mm; Length: 320 mm; Width: 320 mm
Identity Data - Mark: 2; Assembly Code: 18851002; Description: Wash Hands; Manufacturer: Arch Valadares; Model: EROS; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: Washbasin; URL: www.archvaladares.com
Other - Category: Plumbing Fixtures; Family: 18851002: Washbasin; Family and Type: 18851002: Washbasin; Type: 18851002: Washbasin; Type Id: 18851002: Washbasin; Family Name: 18851002
Phasing - Phase Created: New Construction
Materials and Finishes - Material: Porcelain Sanitaryware
Text - Country of Origin: Portugal; Load test (Standard EN): EN 14688:2006; Mechanical resistance (material): 710 kgf/cm2; Performance Certificate: DoP N.14688; Technical Warranty: 20 Years; Weight: 6.8
