Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 0001
Time: 2020-11-07T11:14:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.0.0.383 - Exporter 21.0.0.383 - IU alternativa 21.0.0.383
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Nov 07 11:14:46 2020 * Host: DESKTOP-LA3VOFD * Database: C:\Users\fpinh\AppData\Local\Temp\a2bce8b4-61d9-47cc-a08e-ad6cda49a600\b4c5140d-f942-476b-82da-c34a968e8143\ifc * Database version: 5507 * Database creation date: Sat Nov 07 11:14:44 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Nov 07 11:14:44 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Nov 07 11:14:44 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome do projeto; Phase: Status do projeto

# IfcSite, Default
RefLatitude: -15, -52, 0, -120620; RefLongitude: -47, -55, 0, -114440; RefElevation: 0 mm
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Outros - Categoria: Informações do projeto; Data de emissão do projeto: Data de emissão; Endereço do projeto: Insira aqui o endereço; Nome do cliente: Proprietário; Nome do projeto: Nome do projeto; Número do projeto: 0001; Status do projeto: Status do projeto

# IfcBuildingStorey: Nível:Cabeça de 8 mm, Nível 0
LongName: Nível 0; Elevation: 0 mm
Restrições(Type) - Base da elevação: Ponto base do projeto
Cotas - Cálculo da altura: 0 mm
Dados de identidade - Andar da construção: yes; Estrutural: no; Nome: Nível 0
Outros - Categoria: Níveis; Família: Nível: Cabeça de 8 mm; Família e tipo: Nível: Cabeça de 8 mm; ID de tipo: Nível: Cabeça de 8 mm; Tipo: Nível: Cabeça de 8 mm
Restrições - Elevação: 0 mm
Dados de identidade(Type) - Nome do tipo: Cabeça de 8 mm
Gráficos(Type) - Cor: 0; Espessura da linha: 1; Padrão de linha: Centro (1); Símbolo: M_Cabeça do nível - Círculo: M_Cabeça do nível - Círculo; Símbolo no final 1 padrão: no; Símbolo no final 2 padrão: yes
Outros(Type) - Categoria: Níveis; Nome da família: Nível

# IfcFlowTerminal: 78868002:Washbasin, 78868002:Washbasin:305916
In: Nível 0
Type - Classification: 78868002 (Uniformat); Material: Porcelain Sanitaryware
Type - Cotas - Height: 80 mm; Length: 375 mm; Width: 650 mm
Type - Dados de identidade - Código de montagem: 78868002; Descrição: Recessed Washbasin; Fabricante: Arch Valadares; Modelo: TOLEDO; Nome do tipo: Washbasin; Número OmniClass: 23.45.00.00; Título OmniClass: Sanitary, Laundry, and Cleaning Equipment; URL: www.archvaladares.com
Type - Materiais e acabamentos - Material: Porcelain Sanitaryware
Type - Outros - Categoria: Peças hidrossanitárias; Nome da família: 78868002
Type - Restrições - Elevação padrão: 0 mm
Type - Texto - Country of Origin: Portugal; Load test (Standard EN): EN 14688:2015; Mechanical resistance (material): 710 kgf/cm2; Performance Certificate: DoP N.14688; Weight: 8.5 kg
Type - Pset_ManufacturerTypeInformation - Manufacturer: Arch Valadares
Type - Pset_QuantityTakeOff - Reference: Washbasin
Pset_DistributionFlowElementCommon - Reference: Washbasin; sets with these values: 2
Cotas - Área: 0.348507 m2; Volume: 0.0195661 m3
Dados de identidade - Marca: 22
Fase - Fase criada: Fase 1
Outros - Família: 78868002: Washbasin; Família e tipo: 78868002: Washbasin; ID de tipo: 78868002: Washbasin; Tipo: 78868002: Washbasin
Restrições - Deslocamento do hospedeiro: 0 mm; Elevação do nível: 0 mm; Hospedeiro: Nível : Nível 0; Move com elementos próximos: no; Nível: Nível: Nível 0
Texto - Technical Warranty: 20 Years
