Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2017-03-16T11:00:48
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 16 11:00:48 2017 * Host: DESKTOP-73DSFLP * Database: C:\Users\Fernando\AppData\Local\Temp\{ED06BB50-2FCB-4C0A-B451-C7F1B7CEE9FC}\ifc * Database version: 5507 * Database creation date: Thu Mar 16 11:00:45 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 16 11:00:45 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 16 11:00:45 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: Wall hung WC, 18003002:Wall hung WC:223129
In: Level 1
Classification: 18003002 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Arch Valadares
Pset_DistributionFlowElementCommon - Reference: Wall hung WC
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.525429 m2; Volume: 0.0103327 m3; Height: 375 mm; Length: 520 mm; Width: 360 mm
Identity Data - Mark: 32; Assembly Code: 18003002; Description: Wall hung WC PMR; Manufacturer: Arch Valadares; Model: PMR; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: Wall hung WC; URL: www.archvaladares.com
Other - Category: Plumbing Fixtures; Family: 18003002: Wall hung WC; Family and Type: 18003002: Wall hung WC; Type: 18003002: Wall hung WC; Type Id: 18003002: Wall hung WC; Family Name: 18003002
Phasing - Phase Created: New Construction
Materials and Finishes - Material: Porcelain Sanitaryware
Text - Country of Origin: Portugal; Flush volume (Standard EN): EN 997:2012; Load test (Standard EN): EN 997:2012; Mechanical resistance (material): 710 kgf/cm2; Performance Certificate: DoP N.997; Technical Warranty: 20 Years; Weight: 14.4
