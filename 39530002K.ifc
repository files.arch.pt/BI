Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2018-07-27T13:11:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jul 27 13:11:17 2018 * Host: GoferDesign * Database: C:\Users\Asus\AppData\Local\Temp\{1C26BFD5-B806-4ADE-9137-BC118DA92711}\ifc * Database version: 5507 * Database creation date: Fri Jul 27 13:11:15 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jul 27 13:11:15 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jul 27 13:11:15 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: Urinal, 39530002K:Urinal:6779
In: Level 1
Classification: 39530002K (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Arch Valadares
Pset_DistributionFlowElementCommon - Reference: Urinal
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.671744 m2; Height: 660 mm; Length: 308 mm; Volume: 0.0589069 m3; Width: 338 mm
Identity Data - Mark: 6; Assembly Code: 39530002K; Description: Urinal Back Inlet Water; Manufacturer: Arch Valadares; Model: EGG; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: Urinal; URL: www.archvaladares.com
Materials and Finishes - Material: Gresanit
Other - Category: Plumbing Fixtures; Family: 39530002K: Urinal; Family and Type: 39530002K: Urinal; Type: 39530002K: Urinal; Type Id: 39530002K: Urinal; Family Name: 39530002K
Phasing - Phase Created: New Construction
Text - Country of Origin: Portugal; Load test (Standard EN): EN 13407:2006; Mechanical resistance (material): 510 kgf/cm2; Performance Certificate: DoP N.13407; Technical Warranty: 20 Years; Weight: 17.1
