Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2018-08-13T10:38:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 13 10:38:15 2018 * Host: GoferDesign * Database: C:\Users\Asus\AppData\Local\Temp\{66B3B589-CDAD-4A7A-B389-E7D818C5071B}\ifc * Database version: 5507 * Database creation date: Mon Aug 13 10:38:12 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 13 10:38:13 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 13 10:38:13 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: Shower tray, 78633002:Shower tray:5313
In: Level 1
Classification: 78633002 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Arch Valadares
Pset_DistributionFlowElementCommon - Reference: Shower tray
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.826286 m2; Height: 40 mm; Length: 700 mm; Volume: 0.0254395 m3; Width: 1000 mm
Identity Data - Mark: 4; Assembly Code: 78633002; Description: Shower tray; Manufacturer: Arch Valadares; Model: ARIS; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: Shower tray; URL: www.archvaladares.com
Materials and Finishes - Material: Gresanit
Other - Category: Plumbing Fixtures; Family: 78633002: Shower tray; Family and Type: 78633002: Shower tray; Type: 78633002: Shower tray; Type Id: 78633002: Shower tray; Family Name: 78633002
Phasing - Phase Created: New Construction
Text - Country of Origin: Portugal; Load test (Standard EN): EN 14527:2006; Mechanical resistance (material): 510 kgf/cm2; Performance Certificate: DoP N.14527; Technical Warranty: 20 Years; Weight: 27.2
