Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2018-07-27T11:58:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jul 27 11:58:25 2018 * Host: GoferDesign * Database: C:\Users\Asus\AppData\Local\Temp\{E854898D-CD30-4FD6-A003-1ADFA8E8D703}\ifc * Database version: 5507 * Database creation date: Fri Jul 27 11:58:21 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jul 27 11:58:22 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jul 27 11:58:22 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: WC, 16001002:WC:22723
In: Level 1
Classification: 16001002 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Arch Valadares
Pset_DistributionFlowElementCommon - Reference: WC
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.538915 m2; Volume: 0.0143082 m3; Height: 300 mm; Length: 500 mm; Width: 370 mm
Identity Data - Mark: 25; Assembly Code: 16001002; Description: WC Wall Hung; Manufacturer: Arch Valadares; Model: NEOCLASSICA; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: WC; URL: www.archvaladares.com
Other - Category: Plumbing Fixtures; Family: 16001002: WC; Family and Type: 16001002: WC; Type: 16001002: WC; Type Id: 16001002: WC; Family Name: 16001002
Phasing - Phase Created: New Construction
Materials and Finishes - Material: Porcelain Sanitaryware
Text - Country of Origin: Portugal; Flush volume (Standard EN): EN 997:2012; Load test (Standard EN): EN 997:2012; Mechanical resistance (material): 710 kgf/cm2; Performance Certificate: DoP N.997; Technical Warranty: 20 Years; Weight: 26
