Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2017-03-16T10:43:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 16 10:43:27 2017 * Host: DESKTOP-73DSFLP * Database: C:\Users\Fernando\AppData\Local\Temp\{1BD7A0A6-BB3B-429E-BB1F-2E5D40F4941B}\ifc * Database version: 5507 * Database creation date: Thu Mar 16 10:43:25 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 16 10:43:26 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 16 10:43:26 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: Pedestal, 16200002:Pedestal:209487
In: Level 1
Classification: 16200002 (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Arch Valadares
Pset_DistributionFlowElementCommon - Reference: Pedestal
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.295359 m2; Volume: 0.0076295 m3; Height: 655 mm; Length: 250 mm; Width: 250 mm
Identity Data - Mark: 13; Assembly Code: 16200002; Description: Pedestal; Manufacturer: Arch Valadares; Model: Neoclassica; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: Pedestal; URL: www.archvaladares.com
Other - Category: Plumbing Fixtures; Family: 16200002: Pedestal; Family and Type: 16200002: Pedestal; Type: 16200002: Pedestal; Type Id: 16200002: Pedestal; Family Name: 16200002
Phasing - Phase Created: New Construction
Materials and Finishes - Material: Porcelain Sanitaryware
Text - Country of Origin: Portugal; Mechanical resistance (material): 710 kgf/cm2; Technical Warranty: 20 Years; Weight: 11.2
