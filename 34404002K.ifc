Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2018-07-27T14:59:39
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Alternate UI 17.12.14.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jul 27 14:59:39 2018 * Host: GoferDesign * Database: C:\Users\Asus\AppData\Local\Temp\{E1926607-FCE9-44F3-94D7-F442BB3E7B3A}\ifc * Database version: 5507 * Database creation date: Fri Jul 27 14:59:37 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jul 27 14:59:38 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jul 27 14:59:38 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: Bidet, 34404002K:Bidet:24310
In: Level 1
Classification: 34404002K (Uniformat)
Pset_ManufacturerTypeInformation - Manufacturer: Arch Valadares
Pset_DistributionFlowElementCommon - Reference: Bidet
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.447999 m2; Height: 300 mm; Length: 520 mm; Volume: 0.0240874 m3; Width: 375 mm
Identity Data - Mark: 30; Assembly Code: 34404002K; Description: Bidet Wall Hung; Manufacturer: Arch Valadares; Model: NAUTILUS; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: Bidet; URL: www.archvaladares.com
Materials and Finishes - Material: Porcelain Sanitaryware
Other - Category: Plumbing Fixtures; Family: 34404002K: Bidet; Family and Type: 34404002K: Bidet; Type: 34404002K: Bidet; Type Id: 34404002K: Bidet; Family Name: 34404002K
Phasing - Phase Created: New Construction
Text - Country of Origin: Portugal; Load test (Standard EN): EN 14528:2007; Mechanical resistance (material): 710 kgf/cm2; Performance Certificate: DoP N.14528; Technical Warranty: 20 Years; Weight: 17.1
